# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C516RD+ STC
  cpu: IRAM(0-0x4FF) IROM(0-0xFFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h MatrixLED.c MatrixLED.h
