#include <REGX52.H>
#include "Delay.h"
#include "MatrixLED.h"


void StartGame(int flag)
{
unsigned char code Animation[]={
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0xFE,0x10,0x28,0x44,0x82,0x00,0x42,0xFE,
0x02,0x00,0x80,0x80,0xFE,0x80,0x80,0x7C,
0x82,0x82,0x82,0x7C,0x00,0x00,0x00,0x72,
0x92,0x92,0x9C,0x00,0x80,0x80,0xFE,0x80,
0x80,0x3E,0x48,0x88,0x48,0x3E,0x00,0xFE,
0x90,0x90,0x6E,0x80,0x80,0xFE,0x80,0x80,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
  unsigned char i,Offset=0,Count=0;
	MatrixLED_Init();
	while(flag==0)
	{
		if(P3_1==0)			//如果按下K1
		{
			Delay(20);
			while(P3_1==0);
			Delay(20);
      flag=1;
	  }
		for(i=0;i<8;i++)	
		{
			MatrixLED_ShowColumn(i,Animation[i+Offset]);
		}
		Count++;			
		if(Count>15)
		{
			Count=0;
			Offset+=1;		//??+8,???????
			if(Offset>56)
			{
				Offset=0;
			}
		}
	}
}
